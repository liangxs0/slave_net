# Keil uVision project smart_home.uvprojx, settings and files
target smart_home (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smart_home
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\app;..\boot;..\device;..\system;..\hardware\zigbee_usart;..\hardware\TP4115;..\hardware\WS2812B;..\hardware\BH1750;..\hardware\CO2;..\hardware\myiic;..\hardware\SHT20;..\hardware\USART3;..\hardware\VEML6070;..\hardware\security;..\hardware\PM2.5;..\hardware\A4988;..\hardware\Fan;..\hardware\Relay;..\hardware\EXIT;..\hardware\figure_print;..\hardware\IIC_Master;..\hardware\Lock;..\hardware\RFID;..\hardware\mini12864;..\hardware\debug-usart;..\hardware\beep;..\hardware\RGBled;..\hardware\servo
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: main.c analysis.c function.c config.c
  group hardware
    ../hardware/zigbee_usart/: ZigBee_usart.c
    ../hardware/WS2812B/: WS2812B.c
    ../hardware/TP4115/: TP4115.c
    ../hardware/CO2/: CO2.c
    ../hardware/BH1750/: BH1750.c
    ../hardware/myiic/: myiic.c
    ../hardware/SHT20/: SHT20.c
    ../hardware/USART3/: usart3.c
    ../hardware/VEML6070/: veml6070.c
    ../hardware/security/: security.c security_windows.c
    ../hardware/PM2.5/: PM2.5.c
    ../hardware/A4988/: A4988.c
    ../hardware/Fan/: fan.c
    ../hardware/Relay/: Relay.c
    ../hardware/EXIT/: exti.c
    ../hardware/figure_print/: figure_print.c
    ../hardware/IIC_Master/: iic_master.c
    ../hardware/Lock/: lock.c
    ../hardware/mini12864/: JXL12864G-086.c
    ../hardware/beep/: beep.c
    ../hardware/debug-usart/: Debug_usart.c
    ../hardware/RGBled/: rgb_led.c
    ../hardware/RFID/: rc522.c
    ../hardware/: readme.txt
    ../hardware/servo/: servo.c
  group device
    ../device/: delay.c sys.c Tim.c Tim1.c
  group boot
    ../boot/: startup_stm32f10x_md.s
  group system
    ../system/: core_cm3.c jpstm32_exti.c jpstm32_gpio.c jpstm32_nvic.c jpstm32_sysclk.c
